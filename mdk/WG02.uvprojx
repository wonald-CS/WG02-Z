# Keil uVision project WG02.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WG02 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\mdk;..\App;..\Hal;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\mt;..\OS;..\User
  memory RVCT4: ROM 0x800c800 size 0x33800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Hal
    ../Hal/: hal_led.c hal_timer.c hal_Gpio.c hal_flash.c hal_tftlcd.c hal_wtn6.c hal_task.c hal_al6630.c hal_key.c hal_uart.c hal_adc.c hal_eeprom.c
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group Mt
    ../mt/: mt_flash.c mt_tftlcd.c lcdfont.c mt_task.c mt_api.c mt_wifi.c mt_4G.c mt_mqtt.c mt_driver.c mt_protocol.c MT_MD5.lib mt_lora.lib mt_update.c
  group App
    ../App/: app.c para.c
  group OS
    ../OS/: OS_System.c cpu.c
  group Startup
    ../Startup/: startup_stm32f10x_cl.s
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
